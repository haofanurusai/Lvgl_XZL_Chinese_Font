# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: test +hex
  group Source Group 1
    ./: OLED128x64-SSD1306-SPI-DMA.c
    ../../: lv_font_xzl_16.c
