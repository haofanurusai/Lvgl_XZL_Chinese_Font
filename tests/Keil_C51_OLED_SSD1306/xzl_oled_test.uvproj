# Keil uVision project xzl_oled_test.uvproj, settings and files
target xzl_oled_test (MCS-51)
  device: AI8051U-8Bit Series AI
  cpu: IRAM(0-0xFF) XRAM(0-0x7FFF) IROM(0-0xFFFF) CLOCK(35000000)
  output: xzl_oled_test +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Sources;.\Sources\inc;..\..
  group AiCube
    ./Sources/: OLED128x64-SSD1306-SPI-DMA.c
    ../../: lv_font_xzl_16.c
